# IAR project rx23t_baseflight.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F523T5 R5F523T5
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x800
  General.IStackSize: 0x800
  General.HeapSize: 0x800
  ICCRX.CCIncludePath2: hard_drive; hard_drive\source; hard_drive\header; hard_drive\ov7725; hard_drive\lcd; hard_drive\lcd\st7735s; cg_7725\cg_src; $TOOLKIT_DIR$\inc; D:\rx23t_baseflight\hard_drive
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: rx23t_baseflight.srec
  ILINK.IlinkOutputFile: rx23t_baseflight.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  group cg_src
    cg_7725/cg_src/: r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_icu.c r_cg_icu.h r_cg_icu_user.c r_cg_intprg.c r_cg_macrodriver.h r_cg_main.c r_cg_port.c r_cg_port.h r_cg_port_user.c r_cg_sci.c r_cg_sci.h r_cg_sci_user.c r_cg_systeminit.c r_cg_tmr.c r_cg_tmr.h r_cg_tmr_user.c r_cg_userdefine.h
  group hard_drive/lcd
    hard_drive/lcd/: lcd.c lcd.h LCD_ASCII.h
  group hard_drive/lcd/st7735s
    hard_drive/lcd/st7735s/: lcd_st7735s.c lcd_st7735s.h
  group hard_drive/ov7725
    hard_drive/ov7725/: ov7725.c ov7725.h sccb.c sccb.h
  group hard_drive/user
    hard_drive/user/: delay.c delay.h
